# Keil uVision project dc_base.uvprojx, settings and files
target main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dc_base +hex
  AfterMake: .\HEXBIN.bat $K !L @L $L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\MALLOC;..\USER;..\FWLIB\STM32_ETH_Driver\inc;..\FWLIB\STM32F10x_StdPeriph_Driver\inc;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app;..\INCLUDE;..\LWIP\lwip_app\tcp_client;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip_app\web_server;..\APP\TASK\inc;..\APP\TOOL\inc;..\APP\USER\inc;..\APP\DRIVER\inc;..\HARDWARE\inc;..\LITTLEFS;..\LWIP\lwip_app\onvif;..\LWIP\lwip_app\ping;..\PRINT;..\APP\UPDATE\inc;..\LWIP\lwip-1.4.1\src\include\ipv4\lwip
  memory RVCT4: ROM 0x800e000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP/USR
    ../APP/USER/src/: com.c save.c start.c
  group APP/TASK
    ../APP/TASK/src/: app.c eth.c det.c gsm.c http_update.c
  group APP/INCLUDE
    ../INCLUDE/: appconfig.h bsp.h error.h
  group APP/TOOL
    ../APP/TOOL/src/: crc.c tool.c cJSON.c mycJSON.c Queue.c
  group APP/UPDATE
    ../APP/UPDATE/src/: iap.c update.c update_gsm.c update_lwip.c
  group APP/DRIVER
    ../APP/DRIVER/src/: lan8720.c RN8207C.c key.c led.c aht20.c aht20_drv.c adc.c fan.c relay.c
  group APP/DRIVER/GPRS
    ../APP/DRIVER/src/: GPRS.c GPS.c
  group APP/DRIVER/LIS3DH
    ../APP/DRIVER/src/: hal_lis3dh.c lis3dh_driver.c
    ../HARDWARE/src/: lis3dh_iic.c lis3dh_spi.c
  group APP/DRIVER/FLASH
    ../APP/DRIVER/src/: w25qxx.c
    ../HARDWARE/src/: spi.c
  group APP/PRINT
    ../PRINT/: print.c udp_multicast.c
  group MCU/DRIVER
    ../HARDWARE/src/: dma.c IWDG.c rtc.c timer.c stmflash.c elec_uart.c gsm_usart.c rs485.c usart2.c
  group MCU/USR
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MCU/SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group MCU/CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group MCU/FWLIB
    ../FWLIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
    ../FWLIB/STM32_ETH_Driver/src/: stm32_eth.c
  group MCU/MALLOC
    ../MALLOC/: malloc.c
  group UCOSII/CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII/CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII/PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group LWIP/APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/ping/: lwip_ping.c
  group LWIP/APP/TCP
    ../LWIP/lwip_app/tcp_client/: tcp_client.c
  group LWIP/APP/WEB
    ../LWIP/lwip_app/web_server/: fs.c httpd.c httpd_cgi_ssi.c httpd_ssi.c httpd_cgi.c
  group LWIP/APP/ONVIF
    ../LWIP/lwip_app/onvif/: onvif.c
  group LWIP/NEFIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP/CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP/ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP/API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LIB/LITTLEFS
    ../LITTLEFS/: lfs_util.c lfs.c lfs_port.c
  group README
    ../../: README.TXT 说明.txt
